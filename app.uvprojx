# Keil uVision project app.uvprojx, settings and files
target Project (ARM-GNU)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: app +hex
  group platform
    ./platform/system/: system_cm4.c startup_cm4.S
  group drivers
    ./drivers/peripheral/src/: tremo_adc.c tremo_bstimer.c tremo_crc.c tremo_dac.c tremo_delay.c tremo_dma.c tremo_flash.c tremo_gpio.c tremo_i2c.c tremo_i2s.c tremo_iwdg.c tremo_lcd.c tremo_lptimer.c tremo_lpuart.c tremo_pwr.c tremo_rcc.c tremo_rtc.c tremo_spi.c tremo_system.c tremo_timer.c tremo_uart.c tremo_wdg.c
  group user
    ./usr/src/: App.c main.c sx126x_Init.c tremo_it.c System_Initial.c
  group lora
    ./lora/radio/sx126x/: radio.c sx126x.c
    ./lora/driver/: rtc-board.c sx1262-board.c utilities.c
    ./lora/system/: delay.c timer.c
